# Runtime dependencies for this package.
# Add entries here if this package requires other packages to be
# installed on the target system at runtime.
RDEPENDS:${PN} += "\
    hello-makefile-application \
    hello-cmake-application \
    "
